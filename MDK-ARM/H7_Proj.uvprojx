# Keil uVision project H7_Proj.uvprojx, settings and files
target H7_Proj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF)   CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: H7_Proj
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,TFT96
  c misc: --diag_suppress=111 --diag_suppress=188 --diag_suppress=870 --diag_suppress=3108
  c include: ../Core/Inc;  ../USB_DEVICE/App;  ../USB_DEVICE/Target;  ../Drivers/STM32H7xx_HAL_Driver/Inc;  ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;  ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;  ../Drivers/CMSIS/Include;  ..\Drivers\BSP\ST7735;  ..\Middlewares\sfud\inc;  ..\Drivers\BSP\W25QXX;  ..\lvgl;  ..\lvgl\src;  ..\lvgl\src\lv_core;  ..\lvgl\src\lv_hal;  ..\lvgl\src\lv_misc;  ..\lvgl\src\lv_gpu;  ..\lvgl\src\lv_themes;  ..\lvgl\src\lv_font;  ..\lvgl\src\lv_draw;  ..\lvgl\src\lv_widgets;  ..\lvgl\docs;  ..\FatFs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: debug.c main.c gpio.c rtc.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Drivers/BSP/ST7735
    ../Drivers/BSP/ST7735/: lcd.c st7735.c st7735_reg.c
  group Drivers/BSP/W25Qxx
    ../Drivers/BSP/W25QXX/: w25qxx.c
  group LVGL
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../lvgl/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../lvgl/docs/: color.c CSGO.c image_scen.c lv_demo_benchmark.c my_Font1.c myFont.c
  group Fatfs
    ../FatFs/: diskio.c fatfs-demo.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.3.0
